# IAR project Project.ewp, settings and files
configuration STM32N657_DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657xx ST STM32N657xx
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_STM32N6xx_NUCLEO; USE_FULL_ASSERT; USE_HAL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; USE_CSI_INTERFACE; USE_FREERTOS
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Third_Party\VideoEncoder\inc; ..\..\..\..\Third_Party\VideoEncoder\source\h264; ..\..\..\..\Third_Party\VideoEncoder\source\common; ..\..\Util; ..\..; ..\..\..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\rk050hr18; ..\..\..\..\..\Drivers\BSP\Components\mx66uw1g45g; ..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\ov5640; ..\..\..\..\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\Third_Party\FreeRTOS\Source\include; ..\..\..\..\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32N6xx_Nucleo (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; USE_STM32N6xx_NUCLEO; USE_FULL_ASSERT; USE_HAL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\..\..\n6_master\Firmware\Drivers\CMSIS\Include; ..\..\..\n6_master\Firmware\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\n6_master\Firmware\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\n6_master\Firmware\Drivers\BSP\STM32N6xx_Nucleo; ..\Inc; ..\..\..\n6_master\Firmware\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\Inc\VENC; C:\git\venc\EWL_workspace\Inc\EWL; C:\git\venc\EWL_workspace\Src\VENC\h264; C:\git\venc\EWL_workspace\Src\VENC\common; C:\git\venc\EWL_workspace\Src\VENC\camstab; C:\git\venc\EWL_workspace\Src\VENC\jpeg; C:\git\venc\EWL_workspace\Inc\MM; C:\git\n6_master\Firmware\Drivers\BSP\STM32N6570-DK
  ICCARM.CCOptLevel: 0
  group (top)
    ../: hal_generic_valid_it.c hal_timebase_tim.c main.c
  group BSP
    ../../../../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
    ../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_camera.c stm32n6570_discovery_lcd.c stm32n6570_discovery_sd.c stm32n6570_discovery_xspi.c
  group CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx.s
    ../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_s.c
  group Drivers
    ../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_csi.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_sd.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_usart.c stm32n6xx_ll_sdmmc.c stm32n6xx_ll_venc.c
  group EWL
    ../../: ewl_impl.c
  group FreeRTOS
    ../../../../Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group VSI/Common
    ../../../../Third_Party/VideoEncoder/source/common/: encasiccontroller.c encasiccontroller_v2.c encInputLineBuffer.c encpreprocess.c encswhwregisters.c
  group VSI/h264
    ../../../../Third_Party/VideoEncoder/source/h264/: H264Cabac.c H264CodeFrame.c H264Denoise.c H264EncApi.c h264encapi_ext.c H264Init.c H264Mad.c H264NalUnit.c H264PictureBuffer.c H264PictureParameterSet.c H264PutBits.c H264RateControl.c H264Sei.c H264SequenceParameterSet.c H264Slice.c H264TestId.c
