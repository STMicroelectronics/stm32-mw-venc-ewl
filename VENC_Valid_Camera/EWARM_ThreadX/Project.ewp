# IAR project Project.ewp, settings and files
configuration STM32N657_DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657xx ST STM32N657xx
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_STM32N6xx_NUCLEO; USE_FULL_ASSERT; USE_HAL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; USE_CSI_INTERFACE; USE_THREADX
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Third_Party\VideoEncoder\inc; ..\..\..\..\Third_Party\VideoEncoder\source\h264; ..\..\..\..\Third_Party\VideoEncoder\source\common; ..\..\Util; ..\..; ..\..\..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\rk050hr18; ..\..\..\..\..\Drivers\BSP\Components\mx66uw1g45g; ..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\ov5640; ..\..\..\threadx\common\inc; ..\..\..\threadx\ports\cortex_m55\iar\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_SINGLE_MODE_SECURE
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32N6xx_Nucleo (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; USE_STM32N6xx_NUCLEO; USE_FULL_ASSERT; USE_HAL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\..\..\n6_master\Firmware\Drivers\CMSIS\Include; ..\..\..\n6_master\Firmware\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\n6_master\Firmware\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\n6_master\Firmware\Drivers\BSP\STM32N6xx_Nucleo; ..\Inc; ..\..\..\n6_master\Firmware\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\Inc\VENC; C:\git\venc\EWL_workspace\Inc\EWL; C:\git\venc\EWL_workspace\Src\VENC\h264; C:\git\venc\EWL_workspace\Src\VENC\common; C:\git\venc\EWL_workspace\Src\VENC\camstab; C:\git\venc\EWL_workspace\Src\VENC\jpeg; C:\git\venc\EWL_workspace\Inc\MM; C:\git\n6_master\Firmware\Drivers\BSP\STM32N6570-DK
  ICCARM.CCOptLevel: 0
  group (top)
    ../: hal_generic_valid_it.c hal_timebase_tim.c main.c
  group AzureRTOS/ports
    ../../../threadx/ports/cortex_m55/iar/src/: tx_iar.c tx_initialize_low_level.s tx_misra.s tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_secure_stack.c tx_thread_secure_stack_allocate.s tx_thread_secure_stack_free.s tx_thread_secure_stack_initialize.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s txe_thread_secure_stack_allocate.c txe_thread_secure_stack_free.c
  group AzureRTOS/threadx
    ../../../threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group BSP
    ../../../../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
    ../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_camera.c stm32n6570_discovery_lcd.c stm32n6570_discovery_sd.c stm32n6570_discovery_xspi.c
  group CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx.s
    ../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_s.c
  group Drivers
    ../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_csi.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_sd.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_usart.c stm32n6xx_ll_sdmmc.c stm32n6xx_ll_venc.c
  group EWL
    ../../: ewl_impl.c
  group VSI/Common
    ../../../../Third_Party/VideoEncoder/source/common/: encasiccontroller.c encasiccontroller_v2.c encInputLineBuffer.c encpreprocess.c encswhwregisters.c
  group VSI/h264
    ../../../../Third_Party/VideoEncoder/source/h264/: H264Cabac.c H264CodeFrame.c H264Denoise.c H264EncApi.c h264encapi_ext.c H264Init.c H264Mad.c H264NalUnit.c H264PictureBuffer.c H264PictureParameterSet.c H264PutBits.c H264RateControl.c H264Sei.c H264SequenceParameterSet.c H264Slice.c H264TestId.c
